# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: IO-LED +hex
  c flags: Optimize=9
  group Source Group 1
    ./: GPIO.c main.c delay.c
